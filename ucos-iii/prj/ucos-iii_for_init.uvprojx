# Keil uVision project ucos-iii_for_init.uvprojx, settings and files
target ucos_iii_for_init (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucos_iii_for_init +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ..\src\application\os_cfg;..\src\application\app\inc;..\src\platform\bsp\inc;..\src\OS\uC-CPU;..\src\OS\uC-LIB;..\src\OS\uCOS-III\Source;..\src\OS\uC-CPU\ARM-Cortex-M4;..\src\OS\uCOS-III\Ports\ARM-Cortex-M4;..\src\platform\stdPeripheral\CMSIS\Include;..\src\platform\stdPeripheral\CMSIS\Device\ST\STM32F4xx\Include;..\src\platform\driver\inc;..\src\platform\middleware\inc;..\src\platform\MCU\inc;..\src\platform\stdPeripheral\STM32F4xx_HAL_Driver\Inc;..\src\platform\middleware\LwIP\src\include\lwip;..\src\platform\middleware\LwIP\src\include\lwip\apps;..\src\platform\middleware\LwIP\src\include\lwip\priv;..\src\platform\middleware\LwIP\src\include\lwip\prot;..\src\platform\middleware\LwIP\src\include\netif;..\src\platform\middleware\LwIP\src\include\posix;..\src\platform\middleware\LwIP\src\include\posix\sys;..\src\platform\middleware\LwIP\system\arch;..\src\platform\middleware\LwIP\src\include
  memory RVCT4: ROM 0x8000000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../src/application/app/src/: app.c os_app_hooks.c app_init.c task_control_motor.c task_deal_data.c task_display.c task_gather_dev_status.c task_gather_water_level.c task_gsm.c task_log_history.c task_power_management.c task_system_maintain.c task_test.c lwip.c ethernetif.c tcp_echoserver.c stm32f4xx_hal_msp.c
  group bsp
    ../src/platform/bsp/src/: bsp.c bsp_int.c cpu_bsp.c
  group middleware
    ../src/platform/middleware/src/: common_tools.c fifo.c
  group MCU
    ../src/platform/MCU/src/: system_clock.c adc.c gpio.c i2c.c iwdg.c spi.c timer.c uart.c
  group driver
    ../src/platform/driver/src/: drv_8025t.c drv_fm25v05.c drv_w25q64fv.c
  group stdPeripheral
    ../src/platform/stdPeripheral/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    ../src/platform/stdPeripheral/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_adc.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c stm32f4xx_ll_dma.c
    ../src/platform/stdPeripheral/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group OS/lib
    ../src/OS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../src/OS/uC-LIB/Ports/ARM-Cortex-M4/: lib_mem_a.asm
  group OS/cpu
    ../src/OS/uC-CPU/: cpu_core.c
    ../src/OS/uC-CPU/ARM-Cortex-M4/: cpu_a.asm cpu_c.c
  group OS/core
    ../src/OS/uCOS-III/Ports/ARM-Cortex-M4/: os_cpu_a.asm os_cpu_c.c
    ../src/OS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group LwIP
    ../src/platform/middleware/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c multilink.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../src/platform/middleware/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../src/platform/middleware/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../src/platform/middleware/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../src/platform/middleware/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../src/platform/middleware/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group stdPeripheral/HAL
    ../src/platform/stdPeripheral/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c
